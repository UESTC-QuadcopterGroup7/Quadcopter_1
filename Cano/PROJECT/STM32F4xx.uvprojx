# Keil uVision project STM32F4xx.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: STM32F4xx +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F401xx,USE_STDPERIPH_DRIVER
  c include: ..\DRIVER\CMSIS;..\USER\Core;..\DRIVER\FWLib;..\DRIVER\FWLib\inc;..\USER\Control;..\USER\Drivers;..\USER\Motor;..\USER\Wireless;..\USER\Sensors;..\USER\RC
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group DRIVER/CMSIS
    ../DRIVER/CMSIS/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f401xx.s system_stm32f4xx.c system_stm32f4xx.h stm32f4xx.h
  group DRIVER/FWLib
    ../DRIVER/FWLib/: stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
    ../DRIVER/FWLib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER/Motor
    ../USER/Motor/: MyDShot.c MyDShot.h MyDShot_DMA.c MyDShot_DMA.h MyMotorMixer.c MyMotorMixer.h
  group USER/Core
    ../USER/Core/: main.c Mysystem_clock.c Mysystem_clock.h
  group USER/Sensor
    ../USER/Sensors/: MPU6050.h MyBMP.c MyBMP.h MyHMC5883L.c MyHMC5883L.h MyMPU6050.c MyMPU6050.h MyMS5611.c MyMS5611.h
  group USER/Drivers
    ../USER/Drivers/: Delay.c Delay.h MyDMA.c MyDMA.h MyI2C.c MyI2C.h MyI2S.c MyI2S.h MyUSART.c MyUSART.h
  group USER/RC
    ../USER/RC/: MySBUS.c MySBUS.h MyPPM_temp.c MyPPM_temp.h
  group USER/Wireless
    ../USER/Wireless/: MyHC05.c MyHC05.h
